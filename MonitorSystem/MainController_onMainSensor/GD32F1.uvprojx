# Keil uVision project GD32F1.uvprojx, settings and files
target GD32F1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32F1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: .\User;.\Firmware\GD32F10x_standard_peripheral\Include;.\Firmware\CMSIS\GD\GD32F10x\Include;.\Firmware\CMSIS\GD\GD32F10x\Source\ARM;.\Firmware\CMSIS;.\Firmware;.\User\freertos\include;.\User\freertos\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FW
    ./Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group StartUp
    ./Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group User
    ./User/: main.c gd32f10x_it.c
    ./User/usart/: usart.c
    ./User/ec_01f/: ec_01f.c
  group Freertos
    ./User/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./User/freertos/portable/RVDS/ARM_CM3/: port.c
    ./User/freertos/portable/MemMang/: heap_4.c
